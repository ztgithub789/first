# IAR project CCEmulator_VW.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_BVLOADER; USE_DOUBLE_CAN; ZDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libZox\Zox\drivers\include; ..\..\..\..\..\..\libZox\Zox\utils\include; ..\..\..\..\..\..\libZox\Zox\include; ..\..\..\..\..\..\libZox\Zox; ..\..\..\..\..\..\libZox\Zox\irq; ..\..\..\..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\CAN-Emulator; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\APP\CCEmulator\secure; ..\..\..\..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\..\..\..\libZox\uCOS-II\Source; ..\..\..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\APP\RVC-D02; ..\..\..\..\..\..\libZox\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: CC_C02.bin
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02-TESTER\stm32f10x_flash_release.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER
  ICCARM.CCIncludePath2: ..\..\..\..\libZox\Zox\drivers\include; ..\..\..\..\libZox\Zox\utils\include; ..\..\..\..\libZox\Zox\include; ..\..\..\..\libZox\Zox; ..\..\..\..\libZox\Zox\irq; ..\..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\CAN-Emulator; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\APP\CCEmulator\secure; ..\..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\..\libZox\uCOS-II\Source; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\..\libZox\config
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: ..\..\..\BSP\CAN-Emulator\stm32f10x_flash_release.icf
configuration release_vwTuang (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; vw_Tuang; CarNum41
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
  group (top)
    ../../../: irq_handlers_c.cpp main.cpp
  group app/Car
    ../../Car/: CarInfo.cpp
    ../../Car/vwTuang/: Tester.cpp
  group app/Car/vw_TuAng
    ../../Car/vwTuang/: vwTuangTester.cpp
  group app/CCEmulator
    ../../CCEmulator/: AVMtestermain.cpp
  group app/CCEmulator/ComKeepingTaskTester
    ../../CCEmulator/ComKeepingTaskTester/: ComKeepingTaskTester.cpp ListeningTask.cpp RandomMsgTask.cpp StimTask.cpp
  group app/CCEmulator/secure
    ../../CCEmulator/secure/: Activator.cpp DrvHiResClock.cpp Encryption.cpp GetKey.cpp receiveStr.cpp
  group BSP
    ../../../BSP/: stm32f10x_conf.h
  group BSP/CAN-Emulator
    ../../../BSP/CAN-Emulator/: board.cpp
  group libZox
    ../../../../libZox/: CL_LIB.a
