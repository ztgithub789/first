# IAR project CCEmulator_C02.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_BVLOADER; USE_DOUBLE_CAN; ZDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\libZox\Zox\drivers\include; ..\..\..\libZox\Zox\utils\include; ..\..\..\libZox\Zox\include; ..\..\..\libZox\Zox; ..\..\..\libZox\Zox\irq; ..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C02-TESTER; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\libZox\uCOS-II\Source; ..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\APP\RVC-D02; ..\..\..\libZox\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: CC_C02.bin
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: D:\work\CCEmulator\BSP\C02-TESTER\stm32f10x_flash_release.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER
  ICCARM.CCIncludePath2: ..\..\..\..\libZox\Zox\drivers\include; ..\..\..\..\libZox\Zox\utils\include; ..\..\..\..\libZox\Zox\include; ..\..\..\..\libZox\Zox; ..\..\..\..\libZox\Zox\irq; ..\..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C02-TESTER; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\..\libZox\uCOS-II\Source; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\APP\RVC-D02; ..\..\..\..\libZox\config
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02-TESTER\stm32f10x_flash_release.icf
  group (top)
    ../../../: irq_handlers_c.cpp main.cpp
  group app/AudiQ72014
    ../../Car/AudiQ72014/: AudiQ72014Tester.cpp
  group app/CanHub
    ../../CanHub/: CanHub.cpp
  group app/Car
    ../../Car/: Tester.cpp
  group app/Car/AudiA1
    ../../Car/AudiA12012/: AudiA12012Tester.cpp
  group app/Car/AudiA3_2014
    ../../Car/AudiA3_2014/: AudiA3_2014Tester.cpp
  group app/Car/AudiA4
    ../../Car/AudiA4/: AudiA4Tester.cpp
  group app/Car/AudiA62011b
    ../../Car/AudiA62011b/: AudiA62011bTester.cpp
  group app/Car/AudiA62012
    ../../Car/AudiA62012/: AudiA62012Tester.cpp
  group app/Car/AudiA8
    ../../Car/AudiA8/: AudiA8Tester.cpp
  group app/Car/AudiQ3_2012_imported
    ../../Car/AudiQ3_2012_imported/: AudiQ3_2012_importedTester.cpp
  group app/Car/AudiQ3_2013_domestic
    ../../Car/AudiQ3_2013_domestic/: AudiQ3_2013_domesticTester.cpp
  group app/Car/AudiQ7
    ../../Car/AudiQ7/: AudiQ7Tester.cpp
  group app/Car/AudiQ72012
    ../../Car/AudiQ72012/: AudiQ72012Tester.cpp
  group app/Car/BenZ
    ../../Car/BenZ/: BenZTester.cpp
  group app/Car/BenZ50
    ../../Car/BenZ50_250/: BenZ50Tester.cpp
  group app/Car/BenZ50_500
    ../../Car/BenZ50_500/: BenZ50_500_Tester.cpp
  group app/Car/BMW
    ../../Car/BMW/: BMWTester.cpp
  group app/Car/Golf7
    ../../Car/Golf7/: Golf7Tester.cpp
  group app/Car/Magotan
    ../../Car/Magotan/: MagotanTester.cpp
  group app/Car/Touareg
    ../../Car/Touareg/: TouaregTester.cpp
  group app/CCEmulator
    ../../CCEmulator/: appMain.cpp RandomMsgTask.cpp
  group app/CCEmulator/ComKeepingTaskTester
    ../../CCEmulator/ComKeepingTaskTester/: ComKeepingTaskTester.cpp GetKey.cpp ListeningTask.cpp StimTask.cpp
  group BSP
    ../../../BSP/: stm32f10x_conf.h
  group BSP/C02-TESTER
    ../../../BSP/C02-TESTER/: board.cpp
  group libZox
    ../../../../libZox/: CL_LIB.a
  group libZox/config
    ../../../libZox/config/: app_cfg.h libcommon.h os_cfg.h stm32f10x_conf.h
