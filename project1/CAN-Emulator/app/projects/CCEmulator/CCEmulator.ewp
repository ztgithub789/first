# IAR project CCEmulator.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; ZDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils\include; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\Zox\irq; ..\..\..\Zox\irq\STM32F10xxx; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\D02-AD-TESTER; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM3\CoreSupport; ..\..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\lib\STM32_CPAL_Driver\inc; ..\..\..\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\uCOS-II\Source; ..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\APP\RVC-D02
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: CCEmulator.bin
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\D02-AD-TESTER\stm32f10x_flash_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/CanHub
    ../../CanHub/: CanHub.cpp
  group app/Car
    ../../Car/: Tester.cpp
  group app/Car/AudiA1
    ../../Car/AudiA12012/: AudiA12012Tester.cpp
  group app/Car/AudiA3_2014
    ../../Car/AudiA3_2014/: AudiA3_2014Tester.cpp
  group app/Car/AudiA4
    ../../Car/AudiA4/: AudiA4Tester.cpp
  group app/Car/AudiA62011b
    ../../Car/AudiA62011b/: AudiA62011bTester.cpp
  group app/Car/AudiA62012
    ../../Car/AudiA62012/: AudiA62012Tester.cpp
  group app/Car/AudiA8
    ../../Car/AudiA8/: AudiA8Tester.cpp
  group app/Car/AudiQ3_2012_imported
    ../../Car/AudiQ3_2012_imported/: AudiQ3_2012_importedTester.cpp
  group app/Car/AudiQ3_2013_domestic
    ../../Car/AudiQ3_2013_domestic/: AudiQ3_2013_domesticTester.cpp
  group app/Car/AudiQ7
    ../../Car/AudiQ7/: AudiQ7Tester.cpp
  group app/Car/AudiQ72012
    ../../Car/AudiQ72012/: AudiQ72012Tester.cpp
  group app/Car/AudiQ72014
    ../../Car/AudiQ72014/: AudiQ72014Tester.cpp
  group app/Car/BenZ
    ../../Car/BenZ/: BenZTester.cpp
  group app/Car/BenZ50
    ../../Car/BenZ50/: BenZ50Tester.cpp
  group app/Car/BWM
    ../../Car/BMW/: BMWTester.cpp
  group app/Car/Golf7
    ../../Car/Golf7/: Golf7Tester.cpp
  group app/Car/Magotan
    ../../Car/Magotan/: MagotanTester.cpp
  group app/Car/Touareg
    ../../Car/Touareg/: TouaregTester.cpp
  group app/CCEmulator
    ../../CCEmulator/: appMain.cpp RandomMsgTask.cpp
  group app/CCEmulator/ComKeepingTaskTester
    ../../CCEmulator/ComKeepingTaskTester/: ComKeepingTaskTester.cpp GetKey.cpp ListeningTask.cpp StimTask.cpp
  group BSP
    ../../../BSP/: stm32f10x_conf.h
  group BSP/D02-AD-TESTER
    ../../../BSP/D02-AD-TESTER/: board.cpp
  group Lib/CMSIS
    ../../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib/STM32F10x_StdPeriph_Driver
    ../../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II/Ports/ARM-Cortex-M3/Generic
    ../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Ports/ARM-Cortex-M3/stm32f10x
    ../../../uCOS-II/Ports/ARM-Cortex-M3/stm32f10x/: os_cpu_chip.c
  group uCOS-II/Source
    ../../../uCOS-II/Source/: ucos_ii.c
  group Zox
    ../../../Zox/: Driver.cpp main.cpp zdebug.cpp Zox.cpp ZTask.cpp
  group Zox/drivers
    ../../../Zox/drivers/: DrvCAN.cpp DrvCH7025.cpp DrvDipSwitch.cpp DrvDS241.cpp DrvExti.cpp DrvGPIO.cpp DrvHiResClock.cpp DrvI2C.cpp DrvLED.cpp DrvM3366.cpp DrvPCA82C250.cpp DrvRelay.cpp DrvTJA1041.cpp DrvUSART.cpp GPTimer.cpp
  group Zox/drivers/DrvTW8835
    ../../../Zox/drivers/DrvTW8835/: DrvTW8835.cpp OSD.c OSDFont.c OSDSPI.c RegData.c SPIMap.c
  group Zox/irq
    ../../../Zox/irq/: irq.c irq.h irq_handlers.s irq_handlers_c.cpp
    ../../../Zox/irq/STM32F10xxx/: irq_vect.c
  group Zox/utils
    ../../../Zox/utils/Delay/: Delay.cpp
    ../../../Zox/utils/optparse/: optparse.cpp
    ../../../Zox/utils/Time/: Time.cpp
    ../../../Zox/utils/Timer/: Timer.cpp
  group Zox/utils/Shell
    ../../../Zox/utils/Shell/Commands/: BuiltinCommands.cpp MiscCommands.cpp SendCommand.cpp SetbdCommand.cpp
    ../../../Zox/utils/Shell/: Shell.cpp
  group Zox/utils/StateMachine
    ../../../Zox/utils/StateMachine/doc/: example.cpp
    ../../../Zox/utils/StateMachine/: StateMachine.cpp
