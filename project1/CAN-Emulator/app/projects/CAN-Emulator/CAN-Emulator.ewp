# IAR project CAN-Emulator.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_BVLOADER; USE_DOUBLE_CAN; ZDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libZox\Zox\drivers\include; ..\..\..\..\..\..\libZox\Zox\utils\include; ..\..\..\..\..\..\libZox\Zox\include; ..\..\..\..\..\..\libZox\Zox; ..\..\..\..\..\..\libZox\Zox\irq; ..\..\..\..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\CAN-Emulator; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\APP\CCEmulator\secure; ..\..\..\..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\..\..\..\libZox\uCOS-II\Source; ..\..\..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\APP\RVC-D02; ..\..\..\..\..\..\libZox\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: CC_C02.bin
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02-TESTER\stm32f10x_flash_release.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER
  ICCARM.CCIncludePath2: ..\..\..\..\libZox\Zox\drivers\include; ..\..\..\..\libZox\Zox\utils\include; ..\..\..\..\libZox\Zox\include; ..\..\..\..\libZox\Zox; ..\..\..\..\libZox\Zox\irq; ..\..\..\..\libZox\Zox\irq\STM32F10x_cl; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\CAN-Emulator; ..\..\..\APP\; ..\..\..\APP\CCEmulator; ..\..\..\APP\CCEmulator\include; ..\..\..\APP\CCEmulator\secure; ..\..\..\..\libZox\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\libZox\lib\CMSIS\CM3\CoreSupport; ..\..\..\..\libZox\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\inc; ..\..\..\..\libZox\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\..\libZox\uCOS-II\Source; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\..\libZox\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\; ..\..\..\..\libZox\config
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: ..\..\..\BSP\CAN-Emulator\stm32f10x_flash_release.icf
configuration release_AudiA12012 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiA12012; CarNum1
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiA62011 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiA62011; CarNum2
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiA62012 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiA62012; CarNum3
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ32012 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ32012; CarNum4
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ32013_500 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ32013_500; CarNum5
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ32013_100 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ32013_100; CarNum6
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Audi_A4 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Audi_A4; CarNum7
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ72012 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ72012; CarNum8
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ72014 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ72014; CarNum9
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiA3_2014 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiA3_2014; CarNum10
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_BenZ50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; BenZ50; CarNum11
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_touareg (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; touareg; CarNum12
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Volvo_V40 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Volvo_V40; CarNum13
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_magotan (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; magotan; CarNum14
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_golf7 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; golf7; CarNum15
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_bmw (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; bmw; CarNum16
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Toyota (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Toyota; CarNum17
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_HondaCity (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; HondaCity; CarNum18
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_LandRover (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; LandRover; CarNum19
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Volvo (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Volvo; CarNum21
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Nissan (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Nissan; CarNum22
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_AudiQ72016 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; AudiQ72016; CarNum23
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_peugeot (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; peugeot; CarNum24
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_BenZ45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; BenZ45; CarNum25
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_CadillacXT5 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; CadillacXT5; CarNum26
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Jaguar (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; Jaguar; CarNum27
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_lexus (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; lexus; CarNum28
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration LR_SB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; BenZ45; CarNum29
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration Porschejie (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; BenZ45; CarNum31
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration LR_DB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; BenZ45; CarNum32
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration LR_DH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; LR_DH; CarNum33
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_RangeRover (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; RangeRover; CarNum34
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_Ford (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; FORD; CarNum36
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
configuration release_vwTuang (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ZDEBUG; USE_BVLOADER; vw_Tuang; CarNum41
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: CAN_Emu.bin
  ILINK.IlinkIcfFile: as above
  group (top)
    ../../../: irq_handlers_c.cpp main.cpp
  group app/CanHub
    ../../CanHub/: CanHub.cpp
  group app/Car
    ../../Car/: CarInfo.cpp Tester.cpp
  group app/Car/AudiA1_2012
    ../../Car/AudiA1_2012/: AudiA1_2012Tester.cpp
  group app/Car/AudiA3_2014
    ../../Car/AudiA3_2014/: AudiA3_2014Tester.cpp
  group app/Car/AudiA4
    ../../Car/AudiA4/: AudiA4Tester.cpp
  group app/Car/AudiA6_2011b
    ../../Car/AudiA6_2011b/: AudiA6_2011bTester.cpp
  group app/Car/AudiA6_2012
    ../../Car/AudiA6_2012/: AudiA6_2012Tester.cpp
  group app/Car/AudiA8
    ../../Car/AudiA8/: AudiA8Tester.cpp
  group app/Car/AudiQ3_2012_imported
    ../../Car/AudiQ3_2012_imported/: AudiQ3_2012_importedTester.cpp
  group app/Car/AudiQ3_2013_domestic
    ../../Car/AudiQ3_2013_domestic/: AudiQ3_2013_domesticTester.cpp
  group app/Car/AudiQ7
    ../../Car/AudiQ7/: AudiQ7Tester.cpp
  group app/Car/AudiQ7_2012
    ../../Car/AudiQ7_2012/: AudiQ7_2012Tester.cpp
  group app/Car/AudiQ7_2014
    ../../Car/AudiQ7_2014/: AudiQ7_2014Tester.cpp
  group app/Car/AudiQ7_2016
    ../../Car/AudiQ7_2016/: AudiQ7_2016_common.h AudiQ7_2016Tester.cpp AudiQ7_2016Tester.h
  group app/Car/BenZ
    ../../Car/BenZ/: BenZTester.cpp
  group app/Car/BenZ50_500
    ../../Car/BenZ50_500/: BenZ50_500Tester.cpp
  group app/Car/BMW
    ../../Car/BMW/: BMWTester.cpp
  group app/Car/BMW3_Series
    ../../Car/BMW3_Series/: BMW3_SeriesTester.cpp
  group app/Car/Cadillac_XT5
    ../../Car/Cadillac_XT5/: Cadillac_XT5Tester.cpp
  group app/Car/Ford
    ../../Car/Ford/: FordTester.cpp
  group app/Car/Golf7
    ../../Car/Golf7/: Golf7Tester.cpp
  group app/Car/HondaCity_2014
    ../../Car/HondaCity_2014/: HondaCity_2014Tester.cpp
  group app/Car/HondaVezel
    ../../Car/HondaVezel/: HondaVezelTester.cpp
  group app/Car/LandCruiser
    ../../Car/LandCruiser/: LandCruiserTester.cpp
  group app/Car/LandRover
    ../../Car/LandRover/: LandRoverTester.cpp
  group app/Car/Landrover_DB
    ../../Car/Landrover_DB/: Landrover_DBTester.cpp
  group app/Car/Landrover_DH
    ../../Car/Landrover_DH/: Landrover_DHTester.cpp
  group app/Car/LandRover_Jaguar
    ../../Car/LandRover_Jaguar/: LandRover_JaguarTester.cpp
  group app/Car/LEXUS
    ../../Car/LEXUS/: LEXUSTester.cpp
  group app/Car/LR_B_Sport
    ../../Car/LR_B_Sport/: LR_B_SportTester.cpp
  group app/Car/Magotan
    ../../Car/Magotan/: MagotanTester.cpp
  group app/Car/NissanX_Trail_2015
    ../../Car/NissanX_Trail_2015/: NissanX_Trail_common.h NissanX_TrailTester.cpp NissanX_TrailTester.h
  group app/Car/PEUGEOT
    ../../Car/PEUGEOT/: PEUGEOT_common.h PEUGEOTTester.cpp PEUGEOTTester.h
  group app/Car/Porsche
    ../../Car/Porsche/: PorscheTester.cpp
  group app/Car/RangeRover
    ../../Car/RangeRover/: RangeRoverTester.cpp
  group app/Car/SUZUK
    ../../Car/SUZUK/: SUZUKTester.cpp
  group app/Car/Touareg
    ../../Car/Touareg/: TouaregTester.cpp
  group app/Car/ToyotaVellfire
    ../../Car/ToyotaVellfire/: ToyotaVellfireTester.cpp
  group app/Car/volvo
    ../../Car/volvo/: volvoTester.cpp
  group app/Car/volvo_V40
    ../../Car/volvo_V40/: volvo_V40Tester.cpp
  group app/Car/vw_TuAng
    ../../Car/vwTuang/: vwTuangTester.cpp
  group app/CCEmulator
    ../../CCEmulator/: appMain.cpp
  group app/CCEmulator/ComKeepingTaskTester
    ../../CCEmulator/ComKeepingTaskTester/: ComKeepingTaskTester.cpp ListeningTask.cpp RandomMsgTask.cpp StimTask.cpp
  group app/CCEmulator/secure
    ../../CCEmulator/secure/: Activator.cpp DrvHiResClock.cpp Encryption.cpp GetKey.cpp receiveStr.cpp
  group BSP
    ../../../BSP/: stm32f10x_conf.h
  group BSP/CAN-Emulator
    ../../../BSP/CAN-Emulator/: board.cpp
  group libZox
    ../../../../libZox/: CL_LIB.a
