# IAR project Zox.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; ZDEBUG
  ICCARM.CCIncludePath2: ..\Zox\drivers\include; ..\Zox\utils\include; ..\Zox\include; ..\Zox; ..\Zox\irq; ..\Zox\irq\STM32F10xxx; ..\; ..\BSP; ..\BSP\RVC-D02; ..\APP; ..\APP\include; ..\lib\STM32F10x_StdPeriph_Driver\inc; ..\lib\CMSIS\CM3\CoreSupport; ..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\lib\STM32_CPAL_Driver\inc; ..\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\uCOS-II\Source; ..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Zox.srec
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: ..\bsp\RVC-D02\stm32f10x_flash_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; NDEBUG
  OBJCOPY.OOCOutputFile: rse01.bin
  ILINK.IlinkIcfFile: ..\bsp\RVC-D02\stm32f10x_flash_release.icf
  group app
    ../app/: ActivatorTask.cpp appMain.cpp CanHub.cpp ParkLine.cpp ShiftDetectingTask.cpp SteeringWheelAngleDectingTask.cpp
  group app/CanTP20
    ../app/CanTP20/: CanTP20Client.cpp CanTP20Server.cpp common.cpp
  group BSP
    ../BSP/: stm32f10x_conf.h
  group BSP/RVC-D02
    ../BSP/RVC-D02/: board.cpp
  group Lib/CMSIS
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib/STM32_CPAL_Driver
    ../lib/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback.c
    ../lib/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group Lib/STM32F10x_StdPeriph_Driver
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II/Ports/ARM-Cortex-M3/Generic
    ../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Ports/ARM-Cortex-M3/stm32f10x
    ../uCOS-II/Ports/ARM-Cortex-M3/stm32f10x/: os_cpu_chip.c
  group uCOS-II/Source
    ../uCOS-II/Source/: ucos_ii.c
  group Zox
    ../Zox/: Device.cpp Driver.cpp main.cpp zdebug.cpp Zox.cpp ZTask.cpp
  group Zox/drivers
    ../Zox/drivers/: DrvButton.cpp DrvCAN.cpp DrvCH7025.cpp DrvDipSwitch.cpp DrvDS241.cpp DrvExti.cpp DrvHiResClock.cpp DrvI2C.cpp DrvLED.cpp DrvM3366.cpp DrvPCA82C250.cpp DrvRelay.cpp DrvTJA1041.cpp DrvUSART.cpp GPTimer.cpp NVIC.cpp
  group Zox/drivers/DrvTW8835
    ../Zox/drivers/DrvTW8835/: DrvTW8835.cpp OSD.c OSDFont.c OSDSPI.c RegData.c SPIMap.c
  group Zox/irq
    ../Zox/irq/: irq.c irq.h irq_handlers.s irq_handlers_c.cpp
    ../Zox/irq/STM32F10xxx/: irq_vect.c
  group Zox/utils
    ../Zox/utils/Delay/: Delay.cpp
    ../Zox/utils/Encryption/: Encryption.cpp
    ../Zox/utils/optparse/: optparse.cpp
    ../Zox/utils/Time/: Time.cpp
    ../Zox/utils/Timer/: Timer.cpp
  group Zox/utils/Shell
    ../Zox/utils/Shell/Commands/: BuiltinCommands.cpp MiscCommands.cpp SendCommand.cpp SetbdCommand.cpp
    ../Zox/utils/Shell/: Shell.cpp
  group Zox/utils/StateMachine
    ../Zox/utils/StateMachine/doc/: example.cpp
    ../Zox/utils/StateMachine/: StateMachine.cpp
